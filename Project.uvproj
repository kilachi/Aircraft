# Keil uVision project Project.uvproj, settings and files
target Aircraft (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\CM3;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Aircraft;.\Aircraft\Aircraft;.\Aircraft\Applications;.\Aircraft\Drivers;.\Aircraft\Math;.\Aircraft\System;.\Libraries\USB_hid;.\Libraries\USB_library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Aircraft
    ./Aircraft/Aircraft/: Aircraft.c Aircraft_Config.h stm32f10x_it.c
  group Applications
    ./Aircraft/Applications/: Scheduler.c Scheduler.h AC_Timer.c AC_Timer.h AC_Mpu.c AC_Mpu.h AC_AHRS.c AC_AHRS.h AC_Baro.c AC_Baro.h AC_Baro_Buffer.c AC_Baro_Buffer.h AC_Baro_Glitch.c AC_Baro_Glitch.h AC_InertialNav.c AC_InertialNav.h AC_DT.c AC_DT.h AC_RcData.c AC_RcData.h AC_Controler.c AC_Controler.h AC_AltHold.c AC_AltHold.h AC_Throttle.c AC_Throttle.h AC_Param.c AC_Param.h
  group Drivers
    ./Aircraft/Drivers/: Bsp.c Bsp.h AC_LED.c AC_LED.h AC_Mpu6000.c AC_Mpu6000.h AC_Nrf24l01.c AC_Nrf24l01.h AC_Baro_MS5611.c AC_Baro_MS5611.h
  group System
    ./Aircraft/System/: AC_SPI.c AC_SPI.h AC_Pwm.c AC_Pwm.h AC_Flash.c AC_Flash.h AC_Hid.c AC_Hid.h
  group Math
    ./Aircraft/Math/: AC_FastMath.c AC_FastMath.h AC_Filter.c AC_Filter.h
  group USB
    ./Libraries/USB_hid/: usb_conf.h usb_config.c usb_config.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group USBLib
    ./Libraries/USB_library/: usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_type.h
  group FWLib
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
